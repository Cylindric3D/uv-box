# Repository Cylindric3D/uv-box

File README.md:

Note that documentation and schematics are also available as images in the [GitHub Pages](https://cylindric3d.github.io/uv-box/) site for this project.

Important Plots
===============
* Controller Schematic
* Controller Board: B.Cu
* Controller Board: F.SilkS
* LED Panels Schematic
* LED Panels Board: B.Cu

Tips for Creating the PCB
=========================
For creating the PCBs with UV-sensitive boards:

1. Text on the B.Cu layer should appear mirrored
2. Plot only the bottom copper "B.Cu" layer to PDF, do not mirror it - it should look mirrored in the PDF.
   This is because you want the ink to be as close to the photo-sensitive surface of the PCB as possible.
3. Print the B_Cu.pdf onto transparencies suitable for your printer.

## KiCad design Electronics/controller/controller.kicad_pcb

Parts:
C1, C2, C4: 0.1µF; Capacitor4x3RM2.5
C3: 0.33µF; Capacitor4x3RM2.5
C5, C6: 22pF; Capacitor4x3RM2.5
ENC1: Encoder; ALPS_Encoder-EC12E2420404
IC1: ATMEGA328P-P; DIP-28__600
LED_DISPLAY1: ATA3492BW; 4_Digit-7_Segment_LED-ATA3492BW
P1: POWER; Pin_Header_Angled_1x02
P2: PANEL_1; Pin_Header_Angled_1x02
P3: PANEL_2; Pin_Header_Angled_1x02
P4: PROG; Pin_Header_Angled_1x02
Q1: P55NF; TO-220_FET-GDS_Horizontal
R1, R5, R6, R7, R8, R9, R10, R11: 33R; R3
R2, R3, R4: 10k; R3
R12: 120R; R3
SP1: PIEZO; Pin_Header_Angled_1x02
SW1: SW_PUSH; SW_PUSH-12mm
SW2: RESET; SW_PUSH_SMALL
U1: LM7805CT; TO-220_Neutral123_Horizontal
U2: 74HC595; DIP-16__300
X1: 16MHz; Crystal_HC50-U_Vertical

Connections:
+12V: C3.1, P1.2, P2.2, P3.2, U1.1 (IN)
/12VGND: P2.1, P3.1, Q1.D
/A: R6.1, U2.4 (QE)
/B: R5.1, U2.2 (QC)
/C: R7.1, U2.5 (QF)
/COL: R1.1, U2.6 (QG)
/D: R8.1, U2.1 (QB)
/D2: C2.2, ENC1.B, IC1.4
/D3: C1.1, ENC1.A, IC1.5
/D4: IC1.6, Q1.G, R4.2
/D5: IC1.11, U2.14 (SER)
/D6: IC1.12, U2.12 (RCLK)
/D7: IC1.13, U2.11 (SRCLK)
/D8: IC1.14, R2.1, SW1.1
/D10: IC1.16, LED_DISPLAY1.1 (DIG1)
/D11: IC1.17, LED_DISPLAY1.2 (DIG2)
/D12: IC1.18, LED_DISPLAY1.6 (DIG3)
/D13: IC1.19, LED_DISPLAY1.8 (DIG4)
/E: R9.1, U2.15 (QA)
/F: R10.1, U2.7 (QH)
/G: R11.1, U2.3 (QD)
/PWM9: IC1.15, R12.2
/RX: IC1.2, P4.2
/TX: IC1.3, P4.1
GND: C1.2, C2.1, C3.2, C4.2, C5.1, C6.2, ENC1.C, IC1.8, IC1.22, P1.1, Q1.S, R4.1, SP1.2, SW1.2, SW2.2, U1.2 (GND), U2.8 (GND), U2.13 (G)
unnamed: C5.2, IC1.10, X1.2
unnamed: C6.1, IC1.9, X1.1
unnamed: IC1.1, R3.2
unnamed: LED_DISPLAY1.3 (D), R8.2
unnamed: LED_DISPLAY1.5 (E), R9.2
unnamed: LED_DISPLAY1.11 (F), R10.2
unnamed: LED_DISPLAY1.12 (COL), R1.2
unnamed: LED_DISPLAY1.13 (C), R7.2
unnamed: LED_DISPLAY1.14 (A), R6.2
unnamed: LED_DISPLAY1.15 (G), R11.2
unnamed: LED_DISPLAY1.16 (B), R5.2
unnamed: R12.1, SP1.1
VCC: C4.1, IC1.7, IC1.20, IC1.21, LED_DISPLAY1.4 (COL_AN), R2.2, R3.1, SW2.1, U1.3 (OUT), U2.10 (SRCLR), U2.16 (VCC)

Notes on the sheet:
Power
Panel Control
Dial Input
Switch Input
Display
Buzzer

Board: 2 copper layers, 110.5 x 64.8 mm, 37 parts (1 on the bottom side), 38 nets.

Other parts of the board:
MountingHole_4mm, MountingHole_4mm#2, MountingHole_4mm#3, MountingHole_4mm#4: VAL**; MountingHole_4mm
Symbol_OSHW-Logo_CopperTop: VAL**; Symbol_OSHW-Logo_CopperTop

## KiCad design Electronics/led_panels/led_panels.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82, D83, D84: LED; LED-5MM
P1: CONN_2; bornier2
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: 120; R3

Connections:
+12V: D1.1 (A), D4.1 (A), D7.1 (A), D10.1 (A), D13.1 (A), D16.1 (A), D19.1 (A), D22.1 (A), D25.1 (A), D28.1 (A), D31.1 (A), D34.1 (A), D37.1 (A), D40.1 (A), D43.1 (A), D46.1 (A), D49.1 (A), D52.1 (A), D55.1 (A), D58.1 (A), D61.1 (A), D64.1 (A), D67.1 (A), D70.1 (A), D73.1 (A), D76.1 (A), D79.1 (A), D82.1 (A), P1.2
GND: P1.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2
unnamed: D1.2 (K), D2.1 (A)
unnamed: D2.2 (K), D3.1 (A)
unnamed: D3.2 (K), R1.1
unnamed: D4.2 (K), D5.1 (A)
unnamed: D5.2 (K), D6.1 (A)
unnamed: D6.2 (K), R2.1
unnamed: D7.2 (K), D8.1 (A)
unnamed: D8.2 (K), D9.1 (A)
unnamed: D9.2 (K), R3.1
unnamed: D10.2 (K), D11.1 (A)
unnamed: D11.2 (K), D12.1 (A)
unnamed: D12.2 (K), R4.1
unnamed: D13.2 (K), D14.1 (A)
unnamed: D14.2 (K), D15.1 (A)
unnamed: D15.2 (K), R5.1
unnamed: D16.2 (K), D17.1 (A)
unnamed: D17.2 (K), D18.1 (A)
unnamed: D18.2 (K), R6.1
unnamed: D19.2 (K), D20.1 (A)
unnamed: D20.2 (K), D21.1 (A)
unnamed: D21.2 (K), R7.1
unnamed: D22.2 (K), D23.1 (A)
unnamed: D23.2 (K), D24.1 (A)
unnamed: D24.2 (K), R8.1
unnamed: D25.2 (K), D26.1 (A)
unnamed: D26.2 (K), D27.1 (A)
unnamed: D27.2 (K), R9.1
unnamed: D28.2 (K), D29.1 (A)
unnamed: D29.2 (K), D30.1 (A)
unnamed: D30.2 (K), R10.1
unnamed: D31.2 (K), D32.1 (A)
unnamed: D32.2 (K), D33.1 (A)
unnamed: D33.2 (K), R11.1
unnamed: D34.2 (K), D35.1 (A)
unnamed: D35.2 (K), D36.1 (A)
unnamed: D36.2 (K), R12.1
unnamed: D37.2 (K), D38.1 (A)
unnamed: D38.2 (K), D39.1 (A)
unnamed: D39.2 (K), R13.1
unnamed: D40.2 (K), D41.1 (A)
unnamed: D41.2 (K), D42.1 (A)
unnamed: D42.2 (K), R14.1
unnamed: D43.2 (K), D44.1 (A)
unnamed: D44.2 (K), D45.1 (A)
unnamed: D45.2 (K), R15.1
unnamed: D46.2 (K), D47.1 (A)
unnamed: D47.2 (K), D48.1 (A)
unnamed: D48.2 (K), R16.1
unnamed: D49.2 (K), D50.1 (A)
unnamed: D50.2 (K), D51.1 (A)
unnamed: D51.2 (K), R17.1
unnamed: D52.2 (K), D53.1 (A)
unnamed: D53.2 (K), D54.1 (A)
unnamed: D54.2 (K), R18.1
unnamed: D55.2 (K), D56.1 (A)
unnamed: D56.2 (K), D57.1 (A)
unnamed: D57.2 (K), R19.1
unnamed: D58.2 (K), D59.1 (A)
unnamed: D59.2 (K), D60.1 (A)
unnamed: D60.2 (K), R20.1
unnamed: D61.2 (K), D62.1 (A)
unnamed: D62.2 (K), D63.1 (A)
unnamed: D63.2 (K), R21.1
unnamed: D64.2 (K), D65.1 (A)
unnamed: D65.2 (K), D66.1 (A)
unnamed: D66.2 (K), R22.1
unnamed: D67.2 (K), D68.1 (A)
unnamed: D68.2 (K), D69.1 (A)
unnamed: D69.2 (K), R23.1
unnamed: D70.2 (K), D71.1 (A)
unnamed: D71.2 (K), D72.1 (A)
unnamed: D72.2 (K), R24.1
unnamed: D73.2 (K), D74.1 (A)
unnamed: D74.2 (K), D75.1 (A)
unnamed: D75.2 (K), R25.1
unnamed: D76.2 (K), D77.1 (A)
unnamed: D77.2 (K), D78.1 (A)
unnamed: D78.2 (K), R26.1
unnamed: D79.2 (K), D80.1 (A)
unnamed: D80.2 (K), D81.1 (A)
unnamed: D81.2 (K), R27.1
unnamed: D82.2 (K), D83.1 (A)
unnamed: D83.2 (K), D84.1 (A)
unnamed: D84.2 (K), R28.1

Board: 2 copper layers, 160.0 x 100.0 mm, 118 parts (1 on the bottom side), 86 nets.

Other parts of the board:
MountingHole_3mm, MountingHole_3mm#2, MountingHole_3mm#3, MountingHole_3mm#4: VAL**; MountingHole_3mm
Symbol_OSHW-Logo_CopperTop: VAL**; Symbol_OSHW-Logo_CopperTop

## KiCad design Electronics/uv-box.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48: LED
P1: CONN_2
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24: 330

Connections:
+12V: D1.1 (A), D3.1 (A), D5.1 (A), D7.1 (A), D9.1 (A), D11.1 (A), D13.1 (A), D15.1 (A), D17.1 (A), D19.1 (A), D21.1 (A), D23.1 (A), P1.2 (PM)
GND: P1.1, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2
unnamed: D6.2 (K), R3.1
unnamed: D24.2 (K), R12.1
unnamed: D22.2 (K), R11.1
unnamed: D20.2 (K), R10.1
unnamed: D18.2 (K), R9.1
unnamed: D16.2 (K), R8.1
unnamed: D14.2 (K), R7.1
unnamed: D12.2 (K), R6.1
unnamed: D10.2 (K), R5.1
unnamed: D8.2 (K), R4.1
unnamed: D4.2 (K), R2.1
unnamed: D2.2 (K), R1.1
unnamed: D5.2 (K), D6.1 (A)
unnamed: D23.2 (K), D24.1 (A)
unnamed: D21.2 (K), D22.1 (A)
unnamed: D19.2 (K), D20.1 (A)
unnamed: D17.2 (K), D18.1 (A)
unnamed: D15.2 (K), D16.1 (A)
unnamed: D13.2 (K), D14.1 (A)
unnamed: D11.2 (K), D12.1 (A)
unnamed: D9.2 (K), D10.1 (A)
unnamed: D7.2 (K), D8.1 (A)
unnamed: D3.2 (K), D4.1 (A)
unnamed: D1.2 (K), D2.1 (A)
unnamed: D42.2 (K), R21.1
unnamed: D48.2 (K), R24.1
unnamed: D46.2 (K), R23.1
unnamed: D44.2 (K), R22.1
unnamed: D40.2 (K), R20.1
unnamed: D38.2 (K), R19.1
unnamed: D36.2 (K), R18.1
unnamed: D34.2 (K), R17.1
unnamed: D32.2 (K), R16.1
unnamed: D30.2 (K), R15.1
unnamed: D28.2 (K), R14.1
unnamed: D26.2 (K), R13.1
unnamed: R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2
unnamed: D33.2 (K), D34.1 (A)
unnamed: D25.1 (A), D27.1 (A), D29.1 (A), D31.1 (A), D33.1 (A), D35.1 (A), D37.1 (A), D39.1 (A), D41.1 (A), D43.1 (A), D45.1 (A), D47.1 (A)
unnamed: D47.2 (K), D48.1 (A)
unnamed: D45.2 (K), D46.1 (A)
unnamed: D43.2 (K), D44.1 (A)
unnamed: D41.2 (K), D42.1 (A)
unnamed: D39.2 (K), D40.1 (A)
unnamed: D37.2 (K), D38.1 (A)
unnamed: D35.2 (K), D36.1 (A)
unnamed: D31.2 (K), D32.1 (A)
unnamed: D29.2 (K), D30.1 (A)
unnamed: D27.2 (K), D28.1 (A)
unnamed: D25.2 (K), D26.1 (A)

Board: 2 copper layers, 172.7 x 50.8 mm, 73 parts (0 on the bottom side), 52 nets.

## Commit log

2014-11-29 Initial tests.
2014-11-30 84 LED per panel.
2014-12-01 Full model of the box. Some updated parts for the parts list.
2014-12-01 Clear out pages.
2014-12-01 Create gh-pages branch via GitHub
2014-12-01 Add preview image.
2014-12-01 Add a couple of images.
2014-12-01 Removed missing board image.
2014-12-01 Update full schematic.
2014-12-01 Add initial interface.
2014-12-01 Flipped pin numbers.
2014-12-01 Add second panel, and controller.
2014-12-01 Update box blueprints.
2014-12-02 Update schematics.
2014-12-02 Update parts.
2014-12-02 Updated board layout. Tidied up schematic.
2014-12-02 Update with latest schematics.
2014-12-02 Tweak the layout.
2014-12-02 Tidying.
2014-12-02 Add display driver schematic.
2014-12-02 Updated intro with display driver.
2014-12-02 Updated project file.
2014-12-03 Added a script to extract a BOM from the netlists.
2014-12-03 Couple of minor fixes.
2014-12-04 Totally broken display.
2014-12-05 Update plans.
2014-12-05 Update schematics with new single-SIPO implementation.
2014-12-06 Fix layout.
2014-12-06 Add custom components.
2014-12-07 Created a small breakout board for the LED display.
2014-12-07 Renumbered some sockets. Rerouted pins.
2014-12-07 Teaks to the plans - added a sample of the PCB.
2014-12-07 Ignore component backups.
2014-12-07 Updated images with latest.
2014-12-07 Update code with new pins.
2014-12-08 Renamed my library.
2014-12-09 Trying out a PCB-based LED panel instead of Veroboard.
2014-12-09 Ignore plots.
2014-12-10 Almost ready for production.
2014-12-10 Tweaking some layout stuff.
2014-12-10 Prettification.
2014-12-10 Putting the display onto the board directly.
2014-12-11 Reworking controller board.
2014-12-11 Updated with latest designs.
2014-12-11 Update with single layout board.
2014-12-11 Ignore some temp file types.
2014-12-11 Added missing file.
2014-12-11 Fixed page title.
2014-12-11 Removed page refresh.
2014-12-12 Added full controller schematics.
2014-12-12 Add some links to images in the readme for posterity.
2014-12-12 Added the OSHW logo to the controller.
2014-12-13 Playing with layout.
2014-12-15 Updated to latest schematics.
2014-12-15 Change a couple of footprints.
2014-12-15 Fixed missing image.
2014-12-15 Fixed incorrect URL.
2014-12-15 Added buzzer schematic.
2014-12-15 Updated code with current pins from the schematic. Refactored display code.
2014-12-15 Trying out the hardware.
2014-12-16 Fixed some bad pinouts on the 7-seg.
2014-12-16 Created some clock code.
2014-12-16 Renamed various private variables.
2014-12-17 Added lots of code to the controller.
2014-12-17 Updated schematics after prototype testing.
2014-12-17 Updates with latest schematics.
2014-12-18 Added Beep and Memory classes.
2014-12-18 Added a display mode to allow display of s:ms instead of m:s.
2014-12-18 Lots of updates! Works now.
2014-12-18 Bit of documentation on the controller logic.
2014-12-18 Moved some parts around on the board.
2014-12-18 Tidied up some visual layout issues.
2014-12-18 Added the LED to the custom library to be able to hide pin numbers.
2014-12-18 Got rid of old pcb layout.
2014-12-19 Updated images.
2014-12-19 Trying out AVR.
2014-12-20 Brought back the old veroboard layout - turns out it's better than protoboard :)
2014-12-20 Added some plots for the v1 controller board.
2014-12-20 Made board more home-brew friendly.
2014-12-21 Changes for v1.1
2014-12-22 Fixes based on first real build.
2014-12-22 Added some debugging.
2014-12-22 Updated with live pinouts.
2014-12-23 Tweaking the layout for home etching.
2014-12-23 Version 1.1.
2014-12-23 Some board layout.
2014-12-27 Updated parts list.
2014-12-28 Layout updated.
